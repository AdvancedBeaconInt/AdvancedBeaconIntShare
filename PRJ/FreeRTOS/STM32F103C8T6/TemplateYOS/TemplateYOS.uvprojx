# Keil uVision project TemplateYOS.uvprojx, settings and files
target ABITemplate (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TemplateYOS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\FWLIB\inc;.\CORE;.\USER;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\HARDWARE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group HARDWARE
    ./HARDWARE/: buzzer.c doorctrl.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/delay/: delay.c
